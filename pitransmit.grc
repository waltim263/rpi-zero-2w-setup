options:
  parameters:
    generate_options: no_gui
    id: pitransmit
    output_language: python
    title: pitransmit
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '151800000'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '1'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '2000000'
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (.82,.48,.29,.17,.1,.1,.1,.1)
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    dev_args: driver=uhd,name=B205i,product=B205mini,serial=32951A4,soapy=1,type=b200
    gain0: gain
    gain_type0: normalized
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0, '0']
- [blocks_repeat_0, '0', blocks_float_to_complex_0, '0']
- [blocks_vector_source_x_0, '0', blocks_repeat_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
